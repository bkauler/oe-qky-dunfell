
#R8 20220317 patch for cap_sys_mount, same as used in kernel src.

SRC_URI_append = " file://cap_sys_mount-1.patch"
