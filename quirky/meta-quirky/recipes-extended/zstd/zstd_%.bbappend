
#20220306 R8
PACKAGECONFIG_append = " lz4 lzma zlib"
