
# 20221101
# PR_NUM is defined in local.conf, currently r10
PR = "r${@int(PR_NUM) + 1}"

