
PACKAGECONFIG = "ares brotli icu zlib"

DEPENDS_append_class-target = " nghttp2 libuv"
