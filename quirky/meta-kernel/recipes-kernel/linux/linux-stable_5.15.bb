# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "5"
LINUX_VMINOR = "15"
LINUX_VPATCH = "16"
LINUX_SHA256_TARBALL = ""
LINUX_SHA256_PATCH = ""
require linux-stable.inc

BB_STRICT_CHECKSUM = "0"
SRC_URI[sha256sum] = "ba0a0a14e89f8212bf3effa3e3118da9939e445bab52a6544f9f98a272ff1794"
